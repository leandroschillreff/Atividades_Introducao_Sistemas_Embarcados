# Keil uVision project maquina_cafe_cha.uvproj, settings and files
target Maquina_Cafe_Cha (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: maquina_cafe_cha
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: STARTUP.A51 main.c delay.c
  group Include
    ./: header.h
